options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,2
    label: Center Frequency
    orient: Qt.Horizontal
    start: 80.1e6
    step: '200000'
    stop: 108.1e6
    value: 97.7e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,2
    label: Rx Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '60'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: signal_bandwidth
  id: variable
  parameters:
    comment: |-
      Adjust this value to set the 
      bandwidth of the signal
    value: '5000000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,2
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.9'
    widget: dial
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '24000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/popuser/Desktop/SDR-course-material/Laboratory/Lab_03/Receiver/received.raw
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/popuser/Desktop/SDR-course-material/Laboratory/Lab_03/Receiver/received_lowpass.raw
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume*2
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: /home/popuser/Desktop/SDR-course-material/Laboratory/Lab_03/Receiver/received.wav
    samp_rate: '24000'
  states: {}
- name: limesdr_source_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: signal_bandwidth
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: signal_bandwidth
    calibr_bandw_ch1: 10e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch1: '0'
    gain_dB_ch0: rx_gain
    gain_dB_ch1: '30'
    lna_path_ch0: '2'
    oversample: '0'
    rf_freq: center_freq
    samp_rate: samp_rate
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    beta: '7'
    cutoff_freq: (samp_rate/2-20000)
    decim: '1'
    gain: '1'
    interp: '4'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '10000'
    win: firdes.WIN_KAISER
  states: {}
- name: note_0
  id: note
  parameters:
    note: group member of pulse, pulse-access, and audio
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 0,2,2,2
    size: '200000'
    type: complex
    xmax: '0.01'
    xmin: '-0.01'
    ymax: '0.01'
    ymin: '-0.01'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    alpha1: '0.5'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,2,2
    label1: Tx
    showports: 'True'
    type: complex
    units: dBm
    wintype: firdes.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 2,2,3,2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '20'
    interp: '24'
    taps: ''
    type: fff
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0, '0']
- [limesdr_source_0, '0', blocks_file_sink_0, '0']
- [limesdr_source_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_0, '0', blocks_file_sink_0_0, '0']
- [low_pass_filter_0, '0', qtgui_const_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
